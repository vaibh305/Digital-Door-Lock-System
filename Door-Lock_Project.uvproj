# Keil uVision project Door-Lock_Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Door-Lock_Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: i2cB.c lcd.c delay.c main_door-lock-passwd.c keypad.c
